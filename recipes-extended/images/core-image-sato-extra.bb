require recipes-sato/images/core-image-sato.bb

IMAGE_INSTALL:append = "xf86-video-fbdev"
